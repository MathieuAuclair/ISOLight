# Keil uVision project Isolight.uvprojx, settings and files
target Isolight (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.pdsc
  cpu: CPUTYPE("Cortex-M0")
  output: Isolight
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTARGET_MCU_NRF51_16K_S130 -D__ASSERT_MSG -DTARGET_NRF51822 --no_rtti -DDEVICE_PORTINOUT=1 -DTARGET_MCU_NRF51_16K_BASE -c -DTARGET_NORDIC -DTARGET_MCU_NRF51822 -DDEVICE_PORTOUT=1 -DMBED_BUILD_TIMESTAMP=1499819573.31 -DTARGET_RELEASE --split_sections -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DTARGET_MCU_NRF51 --cpu=Cortex-M0 -DTARGET_MCU_NORDIC_16K -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -D__CORTEX_M0 -DNRF51 -DTOOLCHAIN_ARM_STD --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED -DTARGET_NRF51822_MKIT -DDEVICE_ERROR_PATTERN=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_INTERRUPTIN=1 -D__CMSIS_RTOS --gnu -DFEATURE_BLE=1 -D__MBED_CMSIS_RTOS_CM -DTARGET_MCU_NRF51_16K
  c include: .; shields; BLE_API; BLE_API/ble; BLE_API/ble/services; BLE_API/source; BLE_API/source/services; nRF51822; nRF51822/TARGET_MCU_NRF51822; nRF51822/TARGET_MCU_NRF51822/bootloader; nRF51822/TARGET_MCU_NRF51822/sdk; nRF51822/TARGET_MCU_NRF51822/sdk/script; nRF51822/TARGET_MCU_NRF51822/sdk/source; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/ble_radio_notification; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/ble_services; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/ble_services/ble_dfu; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/common; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/device_manager; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/device_manager/config; nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/peer_manager; nRF51822/TARGET_MCU_NRF51822/sdk/source/device; nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf; nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/ble_flash; nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/delay; nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/hal; nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/pstorage; nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/pstorage/config; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/bootloader_dfu; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/bootloader_dfu/hci_transport; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/crc16; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/experimental_section_vars; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/fds; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/fstorage; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/hci; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/scheduler; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/timer; nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/util; nRF51822/TARGET_MCU_NRF51822/sdk/source/softdevice; nRF51822/TARGET_MCU_NRF51822/sdk/source/softdevice/common; nRF51822/TARGET_MCU_NRF51822/sdk/source/softdevice/common/softdevice_handler; nRF51822/TARGET_MCU_NRF51822/sdk/source/softdevice/s130; nRF51822/TARGET_MCU_NRF51822/sdk/source/softdevice/s130/headers; nRF51822/TARGET_MCU_NRF51822/sdk/source/toolchain; nRF51822/TARGET_MCU_NRF51822/source; nRF51822/TARGET_MCU_NRF51822/source/btle; nRF51822/TARGET_MCU_NRF51822/source/btle/custom; nRF51822/TARGET_MCU_NRF51822/source/common; mbed/.; mbed/TARGET_NRF51822; mbed/TARGET_NRF51822/TARGET_NORDIC; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/crc16; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/scheduler; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/util; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_8_0_0; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s130_nrf51822_1_0_0; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT; mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/device; mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-DTARGET_MCU_NRF51_16K,-DTARGET_NRF51822_MKIT,-DNRF51,-DTARGET_MCU_NRF51_16K_S130,-DTARGET_NRF51822,-DARM_MATH_CM0,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DTARGET_MCU_NORDIC_16K
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/nRF51822.sct
  group BLE_API
    BLE_API/ble/services/: BatteryService.h DeviceInformationService.h DFUService.h EddystoneConfigService.h EddystoneService.h EnvironmentalService.h HealthThermometerService.h HeartRateService.h iBeacon.h LinkLossService.h UARTService.h URIBeaconConfigService.h
    BLE_API/source/: BLE.cpp BLEInstanceBase.cpp DiscoveredCharacteristic.cpp GapScanningParams.cpp
    BLE_API/ble/: BLE.h blecommon.h BLEInstanceBase.h BLEProtocol.h CallChainOfFunctionPointersWithContext.h CharacteristicDescriptorDiscovery.h deprecate.h DiscoveredCharacteristic.h DiscoveredCharacteristicDescriptor.h DiscoveredService.h FunctionPointerWithContext.h Gap.h GapAdvertisingData.h GapAdvertisingParams.h GapEvents.h GapScanningParams.h GattAttribute.h GattCallbackParamTypes.h GattCharacteristic.h GattClient.h GattServer.h GattServerEvents.h GattService.h SafeBool.h SecurityManager.h ServiceDiscovery.h UUID.h
    BLE_API/source/services/: DFUService.cpp UARTService.cpp URIBeaconConfigService.cpp
  group Isolight
    ./: main.cpp mbed_config.h
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/: analogin_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o mbed_retarget.o pinmap.o port_api.o pwmout_api.o serial_api.o sleep.o spi_api.o startup_nRF51822.o sys.o system_nrf51.o twi_master.o us_ticker.o
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/util/: app_error.h app_util.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/scheduler/: app_scheduler.h
    mbed/TARGET_NRF51822/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/device/: cmsis.h cmsis_nvic.h compiler_abstraction.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf_delay.h system_nrf51.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/crc16/: crc16.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT/: device.h PinNames.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/: gpio_object.h objects.h PeripheralNames.h PortNames.h twi_config.h twi_master.h
    mbed/: mbed.h
    mbed/TARGET_NRF51822/TARGET_NORDIC/: mbed_rtx.h
  group nRF51822
    nRF51822/TARGET_MCU_NRF51822/source/common/: ansi_escape.h assertion.h binary.h ble_error.h common.h compiler.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/softdevice/common/softdevice_handler/: ant_stack_handler_types.h ble_stack_handler_types.h softdevice_handler.c softdevice_handler.h softdevice_handler_appsh.c softdevice_handler_appsh.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/util/: app_error.c app_error.h app_util.h app_util_platform.c app_util_platform.h common.h nordic_common.h nrf_assert.c nrf_assert.h sdk_common.h sdk_errors.h sdk_mapped_flags.c sdk_mapped_flags.h sdk_os.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/scheduler/: app_scheduler.c app_scheduler.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/timer/: app_timer.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/common/: ble_advdata.c ble_advdata.h ble_conn_params.cpp ble_conn_params.h ble_conn_state.c ble_conn_state.h ble_date_time.h ble_gatt_db.h ble_sensor_location.h ble_srv_common.c ble_srv_common.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/softdevice/s130/headers/: ble_err.h ble_gap.h ble_gatt.h ble_gattc.h ble_gatts.h ble_hci.h ble_l2cap.h ble_ranges.h ble_types.h nrf_ble.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_mbr.h nrf_sdm.h nrf_soc.h nrf_svc.h softdevice_assert.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/ble_flash/: ble_flash.c ble_flash.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/ble_radio_notification/: ble_radio_notification.c ble_radio_notification.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/bootloader_dfu/: bootloader.h bootloader_types.h bootloader_util.c bootloader_util.h dfu.h dfu_app_handler.c dfu_app_handler.h dfu_bank_internal.h dfu_ble_svc.h dfu_ble_svc_internal.h dfu_init.h dfu_init_template.c dfu_transport.h dfu_types.h
    nRF51822/TARGET_MCU_NRF51822/source/btle/: btle.cpp btle.h btle_advertising.cpp btle_advertising.h btle_discovery.cpp btle_discovery.h btle_gap.cpp btle_gap.h btle_security.cpp btle_security.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/device/: compiler_abstraction.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/crc16/: crc16.c crc16.h
    nRF51822/TARGET_MCU_NRF51822/source/btle/custom/: custom_helper.cpp custom_helper.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/device_manager/: device_manager.h device_manager_peripheral.c
    nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/device_manager/config/: device_manager_cnfg.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/fds/: fds.c fds.h fds_config.h fds_types_internal.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/fstorage/: fstorage.c fstorage.h fstorage_config.h fstorage_nosd.c
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/hci/: hci_mem_pool.c hci_mem_pool.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/bootloader_dfu/hci_transport/: hci_mem_pool_internal.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/ble/peer_manager/: id_manager.c id_manager.h peer_data.c peer_data.h peer_data_storage.c peer_data_storage.h peer_database.c peer_database.h peer_id.c peer_id.h peer_manager_types.h pm_buffer.c pm_buffer.h pm_mutex.c pm_mutex.h
    nRF51822/TARGET_MCU_NRF51822/source/: nRF5xCharacteristicDescriptorDiscoverer.cpp nRF5xCharacteristicDescriptorDiscoverer.h nRF5xDiscoveredCharacteristic.cpp nRF5xDiscoveredCharacteristic.h nRF5xGap.cpp nRF5xGap.h nRF5xGattClient.cpp nRF5xGattClient.h nRF5xGattServer.cpp nRF5xGattServer.h nRF5xn.cpp nRF5xn.h nRF5xSecurityManager.h nRF5xServiceDiscovery.cpp nRF5xServiceDiscovery.h projectconfig.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/delay/: nrf_delay.c nrf_delay.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/hal/: nrf_ecb.c nrf_ecb.h nrf_gpio.h nrf_gpiote.h nrf_nvmc.c nrf_nvmc.h nrf_temp.h nrf_wdt.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/pstorage/: pstorage.c pstorage.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/drivers_nrf/pstorage/config/: pstorage_platform.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/libraries/experimental_section_vars/: section_vars.h
    nRF51822/TARGET_MCU_NRF51822/sdk/source/toolchain/: system_nrf51.h
